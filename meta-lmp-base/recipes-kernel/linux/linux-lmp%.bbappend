SRC_URI += "file://bpf.cfg"

KERNEL_DEBUG = "True"
