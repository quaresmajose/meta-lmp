FILESEXTRAPATHS:prepend:lmp-mfgtool := "${THISDIR}/${PN}-mfgtool:"
