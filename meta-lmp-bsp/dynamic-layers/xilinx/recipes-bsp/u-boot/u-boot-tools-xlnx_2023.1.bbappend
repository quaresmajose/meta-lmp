DEPENDS += "util-linux-libuuid gnutls swig-native"
